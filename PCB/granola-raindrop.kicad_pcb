# Repository michaelswitzer/granola-raindrop

File README.md:

# Raindrop by Granola Arcade

The Raindrop is a button box style arcade controller by Granola Arcade. It is an upgraded version of the <a rel="TrailMix" href="https://github.com/michaelswitzer/granola-trailmix">TrailMix</a>, our first design. It has the same capabilities as the TrailMix but with a fully enclosed case and hotswap sockets that support Kailh Choc v1 and v2 switches. Due to the simple design requiring no tools or additional hardware for assembly, the Raindrop is available at a very competitive price.

You can no longer purchase the Raindrop but you can buy our current controller offerings at https://granola.games

## How to build
To build your own Raindrop, import the PCB designs and bill of materials using KiCAD. I provided a list of parts that use JLCPCB's part assembly services, since that is the company I use to manufacture the PCB. You can use these files as a starting point for building your own PCB.

The .step file for the case is optimized for FDM 3D printers. I recommend PLA with at least 15% infill but you can use any material you wish. The case is designed to be printed on the thin edge on the right side, which can cause some stability challenges when printing. **This orientation is better suited to printers that do not move their print bed side to side, and can be tricky to print on Prusa/Ender/etc. printers.** If you use a "bed slinger" printer such as these, make sure you have good bed adhesion.

You will also need to source your own key switches, hotswap sockets and keycaps. The Raindrop uses Kailh low-profile Choc keyboard switches.

## Firmware
The Raindrop is designed to use the <a rel="GP2040-CE firmware" href="https://github.com/OpenStickCommunity/GP2040-CE">GP2040-CE firmware</a>. You want the .uf2 file for the Raspberry Pi Pico as it has the same pinouts as the Raindrop. If you wish to use different firmware, you can view the schematic files to understand the layout of the board. If you bridge the Boot and GND pins (marked "BOOT" on the PCB) as you plug in the USB cord, you can upload new firmware in .uf2 format.

## Credits
The Raindrop was designed by Michael Switzer. The GP2040-CE firmware is maintained by <a href="https://github.com/OpenStickCommunity">OpenStickCommunity</a>. This project was inspired by the <a href="https://github.com/jfedor2/flatbox">Flatbox</a>.

## KiCad design PCB/granola-raindrop.kicad_pcb

Board: 2 copper layers, 219.7 x 106.9 mm, 48 parts (0 on the bottom side), 38 nets.

Parts:
C1, C2, C17: 10u; C_0805_2012Metric
C3, C4: 27p; C_0402_1005Metric
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16: 100n; C_0402_1005Metric
C8, C10: 1u; C_0402_1005Metric
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1, R5: 1k; C_0402_1005Metric
R2: DNF; C_0402_1005Metric
R3, R4: 27; C_0402_1005Metric
R6, R7: 5.1k; R_0402_1005Metric
SW1, SW2, SW3, SW4, SW5, SW6: 6mm_Button; SW_PUSH_6mm
SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: MX_Switch; SW_Hotswap_Kailh_Choc_V1V2_1.00u
U1: AMS1117-3.3_SOT223; SOT-223-3_TabPin2
U2: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U3: RP2040; RP2040-QFN-56
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-Assembly
Y1: ABLS-12.000MHZ-B4-T; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C2.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, R2.1, U1.2 (VO), U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD)
/1K: SW15.1 (A), U3.8 (GPIO6)
/1P: SW11.1 (A), U3.13 (GPIO10)
/2K: SW16.1 (A), U3.9 (GPIO7)
/2P: SW12.1 (A), U3.14 (GPIO11)
/3K: SW17.1 (A), U3.11 (GPIO8)
/3P: SW13.1 (A), U3.15 (GPIO12)
/4K: SW18.1 (A), U3.12 (GPIO9)
/4P: SW14.1 (A), U3.16 (GPIO13)
/A1: SW4.1 (A), U3.31 (GPIO20)
/A2: SW3.1 (A), U3.32 (GPIO21)
/DOWN: SW8.1 (A), U3.5 (GPIO3)
/L3: SW1.1 (A), U3.29 (GPIO18)
/LEFT: SW7.1 (A), U3.7 (GPIO5)
/QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U3.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U3.51 (QSPI_SD3)
/QSPI_SS: R1.1, R2.2, U2.1 (~CS), U3.56 (QSPI_SS)
/R3: SW2.1 (A), U3.30 (GPIO19)
/RIGHT: SW9.1 (A), U3.6 (GPIO4)
/S1: SW5.1 (A), U3.27 (GPIO16)
/S2: SW6.1 (A), U3.28 (GPIO17)
/UP: SW10.1 (A), U3.4 (GPIO2)
/USB_D+: R3.1, USB1.6 (DP1), USB1.8 (DP2)
/USB_D-: R4.1, USB1.5 (DN2), USB1.7 (DN1)
/XIN: C4.1, U3.20 (XIN), Y1.1
/XOUT: R5.1, U3.21 (XOUT)
/~USB_BOOT: J1.1, R1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.2, R6.2, R7.2, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), SW12.2 (B), SW13.2 (B), SW14.2 (B), SW15.2 (B), SW16.2 (B), SW17.2 (B), SW18.2 (B), U1.1 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD), Y1.2, Y1.4
unnamed: C3.1, R5.2, Y1.3
unnamed: R3.2, U3.47 (USB_DP)
unnamed: R4.2, U3.46 (USB_DM)
unnamed: R6.1, USB1.10 (CC2)
unnamed: R7.1, USB1.4 (CC1)
VBUS: C1.1, U1.3 (VI), USB1.2 (VBUS), USB1.11 (VBUS)

## Commit log

2023-09-27 fix image
2023-09-27 added case
2023-09-27 updated readme build instructions
2023-09-28 readme update
2023-09-28 gerber rename
2023-09-28 readme update wrong file type
2024-04-06 Updated USB port area and menu button tolerances
2024-04-06 Create new LICENSE
2024-04-06 Update readme license info

Notices in the files:
PCB/granola-raindrop.kicad_pcb:
Licensed under Creative Commons
Attribution-NonCommercial-ShareAlike 4.0 International License
